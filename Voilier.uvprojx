# Keil uVision project Voilier.uvprojx, settings and files
target Reel (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet3FISA
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: principal.c principal_final.c
  group Drivers
    ./Driver/: adc.c gpio.c timer.c uart.c
    ./Lib_Com_Periph_2022/: Lib_Com_Periph_2022.lib MyI2C.h MySPI.h
  group Services
    ./Service/: remote.c roll_measurer.c sail.c wheel.c wind_vane.c
target Simulation (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: ProjetVide
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: .\Driver;.\Service;.\Lib_Com_Periph_2022
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
